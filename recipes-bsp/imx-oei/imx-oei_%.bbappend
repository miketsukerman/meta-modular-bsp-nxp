FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:aom5521a1-db2510 = " \
            file://0001-AOM5521-8Gb-16Gb-support.patch \
"
